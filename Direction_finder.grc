options:
  parameters:
    author: Rein Jaks
    generate_options: qt_gui
    id: Direction_finder
    output_language: python
    title: Drone_direction_finder
  states: {}

blocks:
- name: filtri_laius
  id: variable
  parameters:
    value: 2*samp_rate/1024
  states: {}
- name: freq3
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: samp_rate
    value: 1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '10'
  states: {}
- name: sagedus
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 2400e6
    step: 1e6
    stop: 2480e6
    value: 2440.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6
  states: {}
- name: vec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: vector
  id: variable
  parameters:
    value: '128'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate/100+(filtri_laius/2)
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate/100+(filtri_laius/2)
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-sagedus'
    type: float
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 10/gain
    type: float
    vlen: '1024'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
    vlen: vec
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5006'
    psize: '1472'
    type: float
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5007'
    psize: '1472'
    type: float
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5005'
    psize: '1472'
    type: float
    vlen: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Signal converter',   # will show up in GRC
                  in_sig=[np.float32,np.float32,np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              #print("in[0]: ", input_items[0][0])
              #print("in[1]: ", input_items[1][0])
              a = 2*np.pi
              if input_items[0][0] < input_items[1][0]:
                  output_items[0][:] = input_items[2][0] + a
              else:
                output_items[0][:] = input_items[2][0]
              #print(output_items[0])
              return len(output_items[0])
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fft_suurus=1024.0, samp_rate=20000000.0, kesksagedus=446000000.0):  # only default arguments here
      	#, fft_suurus=1024.0, samp_rate=20000000, kesksagedus=446000000
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Pin to frequency',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_suurus = fft_suurus
              self.samp_rate = samp_rate
              self.kesksagedus = kesksagedus

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #k = (self.samp_rate/self.fft_suurus)+self.kesksagedus #Korrutis
              output_items[0][:] = input_items[0] * (self.samp_rate/self.fft_suurus) + self.kesksagedus
              return len(output_items[0])
    fft_suurus: '1024'
    kesksagedus: sagedus
    samp_rate: samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold=1.0, output_value=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='If threshold',   # will show up in GRC
                  in_sig=[np.float32,np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.output_value = output_value

          def work(self, input_items, output_items):
              #print(input_items[0])
              if input_items[0][0] > self.threshold:
                output_items[0][:] = input_items[1]
              else:
                output_items[0][:] = self.output_value
              #print(output_items[0])
              return len(output_items[0])
    output_value: sagedus
    threshold: '1'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: samp_rate
    analog_bandw_ch1: samp_rate
    calibr_bandw_ch0: 120e6
    calibr_bandw_ch1: 120e6
    channel_mode: '2'
    gain_dB_ch0: gain
    gain_dB_ch1: gain
    lna_path_ch0: '1'
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: sagedus
    samp_rate: samp_rate
    serial: 0009060B00473622
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_complex_to_magphase_0, '0']
- [band_pass_filter_0_1_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_sub_xx_0, '1']
- [blocks_complex_to_magphase_0, '1', epy_block_0, '1']
- [blocks_complex_to_magphase_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_magphase_0_0, '1', blocks_sub_xx_0, '0']
- [blocks_complex_to_magphase_0_0, '1', epy_block_0, '0']
- [blocks_max_xx_0_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_max_xx_0_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_probe_signal_x_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_argmax_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_max_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_1_0, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0_1, '0']
- [blocks_short_to_float_0, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', epy_block_0, '2']
- [epy_block_0, '0', blocks_udp_sink_0_1, '0']
- [epy_block_0_0, '0', epy_block_1, '1']
- [epy_block_1, '0', blocks_add_const_vxx_0, '0']
- [epy_block_1, '0', blocks_udp_sink_0_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [limesdr_source_0, '0', blocks_multiply_xx_0_0, '1']
- [limesdr_source_0, '1', blocks_multiply_xx_0, '0']
- [limesdr_source_0, '1', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
